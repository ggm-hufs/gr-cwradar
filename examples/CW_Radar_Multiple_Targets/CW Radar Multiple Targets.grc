<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CW_Radar_Multiple_Targets</value></param>
<param><key>title</key><value>CW Radar Multiple Targets</value></param>
<param><key>author</key><value>Gabriel Gomez Molina</value></param>
<param><key>description</key><value>Continuous Wave Doppler Radar</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>direction_vector_probe</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>max_num_of_targets</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>num_targets_probe</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>speed_vector_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>max_num_of_targets</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_len/2</value></param>
</block>
<block>
<key>cwradar_vector_flip_ff</key>
<param><key>id</key><value>cwradar_vector_flip_ff</value></param>
<param><key>vlen</key><value>fft_len/2</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_len/2</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>int(samp_rate/samp_rate_sink)</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_len)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>complex_to_mag</value></param>
<param><key>vlen</key><value>fft_len</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_full_spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT CW Doppler Radar Receiver Full Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>window.blackmanharris</value></param>
<param><key>notebook</key><value>notebook, 2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT CW Doppler Radar Receiver </value></param>
<param><key>samp_rate</key><value>samp_rate_sink</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>100</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>window.blackmanharris</value></param>
<param><key>notebook</key><value>notebook, 0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>DC_filter</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>[0]*DC_filter_num_elements+[1]*((fft_len/2)-DC_filter_num_elements)</value></param>
<param><key>vlen</key><value>fft_len/2</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>DC_filter_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>[0]*DC_filter_num_elements+[1]*((fft_len/2)-DC_filter_num_elements)</value></param>
<param><key>vlen</key><value>fft_len/2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>DC_filter_num_elements</value></param>
<param><key>label</key><value>DC Filter Num Elements</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_sink</value></param>
<param><key>label</key><value>Sample Rate FFT Sink (Hz)</value></param>
<param><key>value</key><value>8000</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>m</key><value>fft_len/2</value></param>
<param><key>n</key><value>fft_len</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>m</key><value>fft_len/2</value></param>
<param><key>n</key><value>fft_len</value></param>
<param><key>offset</key><value>fft_len/2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset_freq</value></param>
<param><key>label</key><value>Local Oscilator Offset Frequency</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>highpass_cutoff_freq</value></param>
<param><key>label</key><value>High-Pass Cutoff Frequency (Hz)</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_signal_bw</value></param>
<param><key>label</key><value>Doppler Signal Bandwidth (Hz)</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_amp_tuner</value></param>
<param><key>label</key><value>TX Signal Amp</value></param>
<param><key>value</key><value>tx_amp</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,8,1,21</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>threshold_dB_tuner</value></param>
<param><key>label</key><value>Detected Target Threshold (dB)</value></param>
<param><key>value</key><value>threshold_dB</value></param>
<param><key>min</key><value>-90</value></param>
<param><key>max</key><value>-30</value></param>
<param><key>num_steps</key><value>60</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,8</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>usrp_transmitter</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>'addr=192.168.10.2'</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>RF_tuner</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>amp</key><value>tx_amp_tuner</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>RF_tuner</value></param>
<param><key>label</key><value>Radar Frequency (Hz)</value></param>
<param><key>value</key><value>RF</value></param>
<param><key>min</key><value>2.4e9</value></param>
<param><key>max</key><value>2.5e9</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,8</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>max_num_of_targets_tuner</value></param>
<param><key>label</key><value>Maximum Number of Targets</value></param>
<param><key>value</key><value>max_num_of_targets</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>2,8,1,21</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>target_direction_vector</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>direction_vector_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>speed_samp_rate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>target_speed_vector</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>speed_vector_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>speed_samp_rate</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>num_targets_textbox</value></param>
<param><key>label</key><value>Number of Targets Detected</value></param>
<param><key>value</key><value>num_targets</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,4</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>num_targets</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>num_targets_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>speed_samp_rate</value></param>
</block>
<block>
<key>cwradar_doppler_velocity_multiple_targets_ff</key>
<param><key>id</key><value>cwradar_doppler_velocity_multiple_targets_ff_0</value></param>
<param><key>vlen</key><value>fft_len/2</value></param>
<param><key>samples_per_sec</key><value>samp_rate</value></param>
<param><key>radar_freq</key><value>RF_tuner</value></param>
<param><key>signal_min_dB</key><value>threshold_dB_tuner</value></param>
<param><key>angle_of_approach</key><value>angle_tuner</value></param>
<param><key>lowpass_cut_freq</key><value>lowpass_cutoff_freq_tuner</value></param>
<param><key>highpass_cut_freq</key><value>highpass_cutoff_freq_tuner</value></param>
<param><key>max_num_of_targets</key><value>max_num_of_targets_tuner</value></param>
<param><key>doppler_signal_bw</key><value>doppler_signal_bw_tuner</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain_tuner</value></param>
<param><key>label</key><value>USRP RX Gain (dB)</value></param>
<param><key>value</key><value>rx_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>30.5 + 62</value></param>
<param><key>num_steps</key><value>185</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX Gain (dB)</value></param>
<param><key>value</key><value>30.5</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_amp</value></param>
<param><key>label</key><value>TX Amplitude</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_num_of_targets</value></param>
<param><key>label</key><value>Max Num of Targets</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>angle</value></param>
<param><key>label</key><value>Angle (Deg)</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>speed_samp_rate</value></param>
<param><key>label</key><value>Speed Sample Rate (Hz)</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lowpass_cutoff_freq</value></param>
<param><key>label</key><value>Low-Pass Cutoff Frequency (Hz)</value></param>
<param><key>value</key><value>1700</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>value</key><value>pow(2,20)</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RF</value></param>
<param><key>label</key><value>Radio Frequency (Hz)</value></param>
<param><key>value</key><value>2.49e9</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate (Hz)</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold_dB</value></param>
<param><key>label</key><value>Threshold (dB)</value></param>
<param><key>value</key><value>-70</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Time/Frequency CW Doppler Radar Receiver</value></param>
<param><key>samp_rate</key><value>samp_rate_sink</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>100</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>window.blackmanharris</value></param>
<param><key>notebook</key><value>notebook, 1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>speed_textbox</value></param>
<param><key>label</key><value>Targets Speed (Kph)</value></param>
<param><key>value</key><value>target_speed_vector</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,53</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>angle_tuner</value></param>
<param><key>label</key><value>Angle of Approach of the Target (Deg)</value></param>
<param><key>value</key><value>angle</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>89</value></param>
<param><key>num_steps</key><value>890</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,8,1,21</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>highpass_cutoff_freq_tuner</value></param>
<param><key>label</key><value>High-Pass Cutoff Frequency (Hz)</value></param>
<param><key>value</key><value>highpass_cutoff_freq</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1600</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,29,1,24</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>doppler_signal_bw_tuner</value></param>
<param><key>label</key><value>Doppler Spectrum Bandwidth (Hz)</value></param>
<param><key>value</key><value>doppler_signal_bw</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,29,1,24</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>lowpass_cutoff_freq_tuner</value></param>
<param><key>label</key><value>Low-Pass Cutoff Frequency (Hz)</value></param>
<param><key>value</key><value>lowpass_cutoff_freq</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>3000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,29,1,24</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>direction_textbox</value></param>
<param><key>label</key><value>Targets Direction</value></param>
<param><key>value</key><value>target_direction_vector</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,53</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['FFT CW Doppler Radar Receiver', 'Frequency/Time CW Doppler Radar Receiver', 'FFT CW Doppler Radar Receiver Full Spectrum']</value></param>
<param><key>grid_pos</key><value>6,0,13,53</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_receiver</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>'addr=192.168.10.3'</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>mimo</value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(RF_tuner, lo_offset_freq)</value></param>
<param><key>gain0</key><value>rx_gain_tuner</value></param>
<param><key>ant0</key><value>J1</value></param>
<param><key>bw0</key><value>15e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_negative_frequency</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>CW_Radar_MT_neg.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_len/2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_positive_frequency</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>CW_Radar_MT_pos.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_len/2</value></param>
</block>
<connection><source_block_id>complex_to_mag</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>complex_to_mag</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DC_filter</source_block_id><sink_block_id>cwradar_doppler_velocity_multiple_targets_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DC_filter_0</source_block_id><sink_block_id>cwradar_doppler_velocity_multiple_targets_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>cwradar_doppler_velocity_multiple_targets_ff_0</source_block_id><sink_block_id>num_targets_probe</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cwradar_doppler_velocity_multiple_targets_ff_0</source_block_id><sink_block_id>direction_vector_probe</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cwradar_doppler_velocity_multiple_targets_ff_0</source_block_id><sink_block_id>speed_vector_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_0</source_block_id><sink_block_id>DC_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>cwradar_vector_flip_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cwradar_vector_flip_ff</source_block_id><sink_block_id>DC_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_receiver</source_block_id><sink_block_id>wxgui_fftsink2_full_spectrum</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_receiver</source_block_id><sink_block_id>rational_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler</source_block_id><sink_block_id>wxgui_waterfallsink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler</source_block_id><sink_block_id>wxgui_fftsink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>complex_to_mag</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_receiver</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>usrp_transmitter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DC_filter</source_block_id><sink_block_id>file_negative_frequency</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DC_filter_0</source_block_id><sink_block_id>file_positive_frequency</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
